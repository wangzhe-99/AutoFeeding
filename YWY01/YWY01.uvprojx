# Keil uVision project YWY01.uvprojx, settings and files
target YWY01 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YWY01 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\timer;.\SYSTEM\usart;.\USER;.\HARDWARE\RELAY;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\24CXX;.\HAL\WIFI;.\HAL\SERIALPORT;.\HAL\ZIGBEE;.\HAL\RS485;.\PROTOCOL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/timer/: timer.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/RELAY/: relay.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/24CXX/: 24cxx.c
  group HAL
    ./HAL/WIFI/: wifi.c
    ./HAL/SERIALPORT/: serialport.c
  group PROTOCOL
    ./PROTOCOL/: protocol.c serrcu.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c epfile.c usermsg.c
